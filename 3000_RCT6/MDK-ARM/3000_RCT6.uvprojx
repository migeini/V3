# Keil uVision project 3000_RCT6.uvprojx, settings and files
target 3000_RCT6 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: 3000_RCT6 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE
  c misc: --diag_suppress=1,177,550
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;..\Hardware\Detect;..\Hardware\MS1100;..\Hardware\Screen;..\Hardware\Sys;..\App;..\Hardware\AT24C256;..\Hardware\W25Q128;..\Hardware\SDcard;..\Hardware\Detect;D:\b yingyong\keil\ARM\ARMCC\include
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Application/User/Core
    ../Core/Src/: main.c gpio.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
    ./: startup_stm32f103xe.s
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_spi.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group Hardware
    ../Hardware/MS1100/: ms1100.c
    ../Hardware/Screen/: cmd_queue.c hmi_driver.c Screen.c
    ../Hardware/Sys/: sys.c
    ../Hardware/AT24C256/: AT24C256.c
    ../Hardware/W25Q128/: W25Q128.c
    ../Hardware/SDcard/: SDcard.c
  group App
    ../App/: App.c Curvematch.c
    ../Hardware/Detect/: Detect.c
software components: CMSIS:CORE 4.3.0
